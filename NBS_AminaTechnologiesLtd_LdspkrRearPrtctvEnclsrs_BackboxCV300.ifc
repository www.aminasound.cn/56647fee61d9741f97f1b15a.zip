Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:35:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:35:06 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{D399C89F-289A-41BD-859E-AD53AE3E953C}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:34:52 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:35:05 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:35:05 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: BackboxCV300, NBS_AminaTechnologiesLtd_LdspkrRearPrtctvEnclsrs_BackboxCV300:BackboxCV300:324040
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_80_77_28_48 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_LoudspeakerRearProtectiveEnclosures_BackboxCV300; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/hhobz3ol; NBSDescription: Loudspeaker rear protective enclosures; NBSReference: 90-70-10/445; ProductInformation: https://uk.aminasound.com/file-directory/product/accessories/backboxes/datasheet/BackboxCV300_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeaker rear protective enclosures; Uniclass2015Code: Pr_80_77_28_48; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - Weight: 2.37 kg; Dimensions: 451 x 306 x 73 mm; SmokeAndFireHoods: n/a; CavityDepth: 75 mm (minimum); Mounting: Cavity wall backboxes provide a straightforward and consistent mounting platform for Amina invisible loudspeakers, achieves ideal speaker alignment in 12.5mm plasterboard, and other thicknesses are easily acommodated with the use of alignment shims. The backbox 'floats' on the rear side of the plasterboard and does not fix to the framework, minimising the likelihood of mechanical noise transmission from the speaker into the structure of the building; RequiredPlasterboardCutout: 404 x 304 mm; SoundPressureAttenuation: 26 dB on average over 150 Hz – 5 kHz range; SpeakerCableEntry: Rubber grommet (can be replaced by M20 gland); SpeakerFixing: Four self tapping flange-head screws (supplied); WallFixing: Eight self tapping drywall screws (supplied)
Type - Pset_BuildingElementProxyCommon - IsExternal: no; LoadBearing: no; ThermalTransmittance: 0; FireRating: n/a; Reference: n/a
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_80_77_28_48:Loudspeaker rear protective enclosures; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Cavity backbox which is an easy to install mounting option in plasterboard cavity walls (drywall) for 300 x 400 mm Amina Invisible Loudspeakers (Mobius3, Edge3i); DurationUnit: year; ExpectedLife: n/a; Features: Creates an acoustically tuned and consistent cavity behind the speaker, helping to ensure both consistent loudspeaker audio quality as well as minimizing rearward airborne sound transmission, the easiest way of mechanically fixing the loudspeaker to the plasterboard whilst also limiting rearward airborne transmission and helping to achieve consistent loudspeaker performance; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: CV300; ModelReference: Backbox CV300; Name: LoudspeakerRearProtectiveEnclosures_BackboxCV300_AminaTechnologiesLtd; NominalHeight: 451 mm; NominalLength: 306 mm; NominalWidth: 73 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 451 x 306 x 73 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
